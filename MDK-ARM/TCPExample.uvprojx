# Keil uVision project TCPExample.uvprojx, settings and files
target TCPExample (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F107RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: TCPExample
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC
  c include: ../Inc;         ../Middlewares/Third_Party/LwIP/src/include;         ../Middlewares/Third_Party/LwIP/system;         ../Drivers/STM32F1xx_HAL_Driver/Inc;         ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;         ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;         ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;         ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;         ../Middlewares/Third_Party/FreeRTOS/Source/include;         ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;         ../Middlewares/Third_Party/LwIP/src/include/lwip;         ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;         ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;         ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;         ../Middlewares/Third_Party/LwIP/src/include/netif;         ../Middlewares/Third_Party/LwIP/src/include/posix;         ../Middlewares/Third_Party/LwIP/src/include/posix/sys;         ../Middlewares/Third_Party/LwIP/system/arch;         ../Drivers/CMSIS/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f107xc.s
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: pppol2tp.c chap-md5.c mppe.c pppapi.c pppos.c ipcp.c chap_ms.c magic.c pppcrypt.c eui64.c auth.c utils.c multilink.c fsm.c upap.c demand.c vj.c eap.c chap-new.c ppp.c ecp.c pppoe.c lcp.c ipv6cp.c ccp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: icmp6.c inet6.c ip6_frag.c dhcp6.c ip6_addr.c ethip6.c nd6.c ip6.c mld6.c
    ../Middlewares/Third_Party/LwIP/src/api/: err.c api_msg.c api_lib.c tcpip.c sockets.c netifapi.c netdb.c netbuf.c
    ../Middlewares/Third_Party/LwIP/src/netif/: slipif.c lowpan6.c ethernet.c
    ../Middlewares/Third_Party/LwIP/src/core/: tcp.c netif.c inet_chksum.c dns.c mem.c tcp_out.c sys.c tcp_in.c memp.c pbuf.c udp.c raw.c timeouts.c stats.c init.c ip.c def.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_frag.c ip4.c autoip.c ip4_addr.c igmp.c dhcp.c etharp.c icmp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_uart.c stm32f1xx_hal_eth.c stm32f1xx_hal_tim.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_hal.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_i2c.c stm32f1xx_hal_cortex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c tasks.c queue.c list.c croutine.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Application/User
    ../Src/: stm32f1xx_it.c freertos.c ethernetif.c lwip.c stm32f1xx_hal_msp.c main.c stm32f1xx_hal_timebase_TIM.c lwiperf.c ping.c
software components: CMSIS:CORE 4.3.0
